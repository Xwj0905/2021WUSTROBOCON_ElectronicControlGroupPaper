# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../../51标准project/12-1 AT24C02数据存储/: SEND.c SEND.h XUNZHI.c XUNZHI.h LCD1602.c LCD1602.h Delay.c Delay.h I2C.c I2C.h Key.c Key.h
